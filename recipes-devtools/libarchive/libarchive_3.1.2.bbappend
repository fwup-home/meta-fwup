PACKAGECONFIG_append = " zlib"